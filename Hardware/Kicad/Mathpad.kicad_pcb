# Repository mbayrao/YMC-Mathpad

File README.md:

# YMC-Mathpad

## **Overview**

這是我第一次用Git…有好多操作要學…Work on it...

這款鍵盤靈感來自Summa-Congni/Mathpad，當我在2025年的某日給女朋友看到能夠方便輸入數學符號的Mathpad
她知道我喜歡也能製做出電路板，便鼓勵我著手製作此project而誕生。
此板為第一版設計，製作時有許多問題導致設計不斷變更直到最後。
主要思路為無線藍芽連接內置5V USB Type C充電電路並提供電量指示燈、有OLED螢幕可供視覺回饋挑選符號

* **Wireless**：Buletooth 5
* **Screen Size**：0.96 inch
* **Layout**：正交排列,按鍵數量6(Maxium: 12) 鍵位配置為上、下、左、右、Enter及切換下一頁的Layer鍵
* **MCU**： ESP32-C3FH4
* **Firmware**：自訂韌體(使用Arduino IDE)
* **Battery life**： 5hrs(600mAh lithium batteries)
* **Mathematical Symbols**：56個符號(一頁14個，共四頁)，根據需求還可以再擴充
* **Dimension**：101mm x 87mm x 13mm

## **Features**

使用Gateron Low Profile THT軸體搭配白色矮鍵，
0.96吋雙色I2C OLED螢幕顯示現在電量、數學符號及實際發送文字

數學符號 

Layer1： ±×÷…≤≥≠√∑∏∞αβγ

Layer2： δεμφπσθ∈∉∫∂∆∇≈

Layer3： ≅≡∪∩≃≄∨∧∴∵⊆⊇⊂⊃

Layer4： ⊗⊕⊙∀∃ℕℤℚℝℍℙρ⇒⇔

## **Repository Contents**
此 Repository 包含自行製作一把鍵盤所需的所有檔案：

| Folder | Contents |
| ----- | ----- |
| `/hardware/pcb` | KiCad/Eagle 電路圖、PCB 佈局、Gerber 製造檔、BOM |
| `/hardware/cad` | CAD 原始檔（STEP）、外殼／定位板 STEP 輸出檔 |
| `/firmware` | 韌體原始碼 |

## **Build Instructions**

1. **PCB**：使用 `/hardware/pcb/gerbers` 中的 Gerber 製造檔，向 \[JLCPCB/PCBWay/其他\] 下單製作。  
2. **Case**：使用 `/hardware/cad` 中的 STEP 檔進行 3D 列印或 CNC 加工。  
4. **Firmware**：依照Arduino IDE方式進行韌體燒錄。

## **CAD / Case Files**

* **Format**：STEP（可編輯）、STL（可直接列印）  
* **Software used**：\[Fusion 360 / FreeCAD / SolidWorks\]  
* **Location**：`hardware/cad/`

## **Wiring / Schematic**

完整電路圖 PDF：[hardware/pcb/YMC_Mathpad_v1.pdf](https://github.com/mbayrao/YMC-Mathpad/blob/main/Hardware/YMC_Mathpad_v1.pdf)

## **Credits / Acknowledgments**

本專案受到 [Mathpad](https://github.com/Summa-Cogni/Mathpad)（作者：\[nup002\dancergraham]）的啟發，並以其為基礎進行開發。

## **Disclaimer**

本專案為業餘／開源專案，以「現況」提供，不提供任何保固。下單或焊接前，請確認所有元件的規格與額定值符合需求。

## KiCad design Hardware/Kicad/Mathpad.kicad_pcb

File Hardware/Kicad/Readme.md:

Mathpad PCB files

This folder contains the schematics and design files for the Mathpad PCB.

The folder kicad contains the full KiCAD project file. Download the open source KiCAD EDA to open it.

Parts:
C10, C11, C13: 47uF X5R; C_0603_1608Metric; LCSC Part # C140782
C12: 1uF_0402; C_0402_1005Metric; LCSC Part # C52923
C14: 100nF; C_0402_1005Metric; LCSC Part # C85858
C15: 10uF; C_0603_1608Metric; LCSC Part # C6119842
C16: 47uF X5R; C_0603_1608Metric; LCSC Part # C140782; not fitted
D1: MBR120VLSFT; D_SOD-123; LCSC Part # C223608
DP1: Red; LED_0603_1608Metric; LCSC Part # C965799
DP2: Green; LED_0603_1608Metric; LCSC Part # C22371297
F1: 1A; Fuse_0805_2012Metric; MPN BSMD0805-050-24V; LCSC C910822
IC1: RT6154AGQW; SON50P300X400X80-15N-D; Manufacturer_Part_Number RT6154AGQW; Mouser Part Number 835-RT6154AGQW
IC2: TP4054; SOT-23-5; Manufacturer_Part_Number TP4054; LCSC Part # C5381776
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4110; LCSC Part # C5187472
J3: BATT; JST_ZH_S2B-ZR-SM4A-TF_1x02-1MP_P1.50mm_Horizontal; LCSC Part # C19272405
L2: 2.2uH 3A; L_1008_2520Metric; LCSC Part # C5832372
Q1: AO3401A; SOT-23; LCSC Part # C15127
Q31: MMBT2222A; SOT-23; LCSC Part # C82460
R1: 560k_0402_1%; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C137958
R2: 100k_0402_1%; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C60491
R3, R4: 100k 1%; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C60491
R5: 3.3k_0603_1%; R_0603_1608Metric; LCSC C22978
R6: 68k_0603; R_0603_1608Metric; LCSC C22978
R9: 680_0603; R_0603_1608Metric; LCSC C22978
R10, R18: 5.1k 1%; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C25905
R13: 10k; R_0402_1005Metric; LCSC Part # C60490
S1: MSK12C02; Manufacturer_Part_Number MSK12C02; LCSC Part # C431540
TP1: TestPoint; TestPoint_Pad_1.5x1.5mm
U1: USBLC6-2P6; SOT-666; LCSC Part # C15999

Connections:
+3.3VP: C10.1, C11.1, IC1.4 (VOUT_1), IC1.5 (VOUT_2), R1.1; also elsewhere on the board
/EN: IC1.12 (EN), R4.2, S1.B1 (COM)
/MP1: S1.MP1, S1.MP2
/MP2: S1.MP3, S1.MP4
/PORT+: J1.A6 (D+), J1.B6 (D+), U1.6 (I/O1)
/PORT-: J1.A7 (D-), J1.B7 (D-), U1.4 (I/O2)
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, IC1.2 (GND), IC1.15 (PGND), IC2.2 (GND), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.2, Q31.2 (E), R2.2, R3.1, R5.1, R10.1, R18.1, S1.C1 (NO), U1.2 (GND); also elsewhere on the board
unnamed: D1.2 (A), F1.2, U1.5 (VBUS)
unnamed: DP1.1 (K), IC2.1 (~CHRG), R6.2, R13.1
unnamed: DP2.1 (K), Q31.3 (C)
unnamed: IC1.3 (FB), R1.2, R2.1
unnamed: IC1.8 (LX1_1), IC1.9 (LX1_2), L2.2
unnamed: IC1.6 (LX2_1), IC1.7 (LX2_2), L2.1
unnamed: IC1.13 (PS/SYNC), R3.2, TP1.1
unnamed: C14.1, IC1.1 (VINA)
unnamed: C15.1, IC2.3 (BAT), J3.1, Q1.2 (S)
unnamed: IC2.5 (PROG), R5.2
unnamed: J1.A5 (CC1), R18.2
unnamed: J1.B5 (CC2), R10.2
unnamed: Q31.1 (B), R6.1
USB+: U1.1 (I/O1); also elsewhere on the board
USB-: U1.3 (I/O2); also elsewhere on the board
VSYS: C13.1, C16.1, D1.1 (K), IC1.10 (VIN_1), IC1.11 (VIN_2), Q1.3 (D), R4.1

Notes on the sheet:
90Ω差分線
USB, ESD protection
Mount 3.3k temporary
PWR ON
PWR OFF
臥貼比沉板便宜
Charge current ~300mA
BATT output when Vbus=0

Parts:
ANT1: ANT3216LL00R2400A; Manufacturer_Part_Number ANT3216LL00R2400A; Mouser Part Number 603-ANT3216LL00R2400
C8, C9: 13pF; C_0402_1005Metric; LCSC Part # C45359988
C17, C18: 3.3pF; C_0402_1005Metric; LCSC Part # C76906
C20: 100nF; C_0402_1005Metric; LCSC Part # C1525
C21, C27: 1uF; C_0402_1005Metric; LCSC Part # C52923
C22, C24, C25, C26, C28: 100n; C_0402_1005Metric; LCSC Part # C1525
C23: 10u; C_0402_1005Metric; LCSC Part # C76991
D2: LED_Dual_AKA; LED_D3.0mm-3; not fitted
J2: COM; PinHeader_1x04_P2.00mm_Vertical; not fitted
L1: 24nH; L_0402_1005Metric; LCSC Part # C330863
L3: 2.2nH; L_0402_1005Metric; LCSC Part # C86061
L4: 2nH; L_0402_1005Metric; LCSC Part # C18216
R11, R16, R17, R19: 10k; R_0402_1005Metric; LCSC Part # C60490
R12: 10k; R_0402_1005Metric; LCSC Part # C60490; not fitted
R14, R15: 100R; R_0603_1608Metric; LCSC Part # C105588
SW17, SW18: Boot; SW_Push_SPST_NO_Alps_SKRK; LCSC Part # C18077675
U2: ESP32-C3FH4; QFN-32-1EP_5x5mm_P0.5mm_EP3.7x3.7mm; LCSC Part # C2858491
Y1: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC Part # C18221407

Connections:
+3.3VP: C20.1, C21.1, C23.1, C24.1, C26.1, C27.1, C28.1, J2.1, L4.1, R11.1, R12.2, R16.1, R17.1, R19.1, U2.11 (VDD3P3_RTC), U2.17 (VDD3P3_CPU), U2.18 (VDD_SPI), U2.31 (VDDA), U2.32 (VDDA); also elsewhere on the board
/KeyPad/COL0: U2.10 (MTDI); also elsewhere on the board
/KeyPad/COL1: U2.12 (MTCK); also elsewhere on the board
/KeyPad/COL2: U2.13 (MTDO); also elsewhere on the board
/KeyPad/COL3: U2.16 (GPIO10); also elsewhere on the board
/KeyPad/ROW0: U2.4 (XTAL_32K_P); also elsewhere on the board
/KeyPad/ROW1: U2.5 (XTAL_32K_N); also elsewhere on the board
/KeyPad/ROW2: U2.8 (GPIO3); also elsewhere on the board
/KeyPad/ROW3: U2.9 (MTMS); also elsewhere on the board
/MCU/Chip_EN: C25.1, R19.2, SW18.2 (B), U2.7 (CHIP_EN)
/MCU/LED_G: J2.2, R14.2, U2.28 (U0TXD)
/MCU/LED_R: J2.3, R15.2, U2.27 (U0RXD)
GND: C8.2, C9.1, C17.1, C18.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, D2.2 (K), J2.4, SW17.1 (A), SW18.1 (A), U2.33 (GND), Y1.2, Y1.4; also elsewhere on the board
GNDA: ANT1.2
unnamed: ANT1.1, C18.2, L3.2
unnamed: C8.1, L1.1, Y1.1
unnamed: C22.1, L4.2, U2.2 (VDD3P3), U2.3 (VDD3P3)
unnamed: D2.1 (A1), R14.1
unnamed: D2.3 (A2), R15.1
unnamed: R11.2, SW17.2 (B), U2.15 (GPIO9)
unnamed: R16.2, U2.6 (GPIO2)
unnamed: R17.2, U2.14 (GPIO8)
unnamed: C17.2, L3.1, U2.1 (LNA_IN)
unnamed: R12.1, U2.21 (SPICS0)
unnamed: C9.2, U2.29 (XTAL_N), Y1.3
unnamed: L1.2, U2.30 (XTAL_P)
USB+: U2.26 (GPIO19); also elsewhere on the board
USB-: U2.25 (GPIO18); also elsewhere on the board

Notes on the sheet:
GPIO1
GPIO4
GPIO5
VPSI
GPIO6
VDDA
GPIO20
GPIO21
GPIO7
GPIO0
'Light' low-pass filter for analog VDD
50ohm
Internal Flash 4MB

Parts:
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: 1N5817WS; D_SOD-123; LCSC Part # C727113; not fitted
SW1, SW3, SW7, SW8, SW9, SW13: SW_Push; SW_Gateron_LowProfile_THT
SW2, SW4, SW5, SW6, SW10, SW11, SW12, SW14, SW15, SW16: SW_Push; SW_Gateron_LowProfile_THT; not fitted

Connections:
/KeyPad/COL0: SW1.2, SW5.2, SW9.2, SW13.2; also elsewhere on the board
/KeyPad/COL1: SW2.2, SW6.2, SW10.2, SW14.2; also elsewhere on the board
/KeyPad/COL2: SW3.2, SW7.2, SW11.2, SW15.2; also elsewhere on the board
/KeyPad/COL3: SW4.2, SW8.2, SW12.2, SW16.2; also elsewhere on the board
/KeyPad/ROW0: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K); also elsewhere on the board
/KeyPad/ROW1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K); also elsewhere on the board
/KeyPad/ROW2: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K); also elsewhere on the board
/KeyPad/ROW3: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K); also elsewhere on the board
unnamed: D3.2 (A), SW1.1
unnamed: D4.2 (A), SW2.1
unnamed: D5.2 (A), SW3.1
unnamed: D6.2 (A), SW4.1
unnamed: D7.2 (A), SW5.1
unnamed: D8.2 (A), SW6.1
unnamed: D9.2 (A), SW7.1
unnamed: D10.2 (A), SW8.1
unnamed: D11.2 (A), SW9.1
unnamed: D12.2 (A), SW10.1
unnamed: D13.2 (A), SW11.1
unnamed: D14.2 (A), SW12.1
unnamed: D15.2 (A), SW13.1
unnamed: D16.2 (A), SW14.1
unnamed: D17.2 (A), SW15.1
unnamed: D18.2 (A), SW16.1

Notes on the sheet:
KeyPad 4x4

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
Board: 4 copper layers, 92.0 x 78.0 mm, 93 parts (17 on the bottom side), 64 nets.
